# Keil uVision project rtx_demo_cm0p.uvproj, settings and files
target Debug (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: rtx_demo
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output rtx_demo_cm0p.hex
  c flags: Optim=4
  c define: CORTEX_M0PLUS
  c include: ..\..\..\..\software\cmsis\CMSIS\Include; ..\..\..\..\software\cmsis\Device\ARM\CMSDK_CM0plus\Include; ..\..\..\..\software\common\retarget
  memory RVCT1: ROM 0x0 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x10000
  group Startup
    ../../../../software/cmsis/Device/ARM/CMSDK_CM0plus/Source/ARM/: startup_CMSDK_CM0plus.s
  group Application
    ./: rtx_demo.c
    ../../../../software/common/retarget/: uart_stdout.c retarget.c
  group System
    ./: RTX_Config.c
    ../../../../software/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
