# Keil uVision project interrupt_demo_cm0p.uvproj, settings and files
target Debug (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: interrupt_demo
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output interrupt_demo.hex
  c flags: Optim=3
  c define: CORTEX_M0PLUS
  c include: ..\..\..\..\software\cmsis\CMSIS\Include; ..\..\..\..\software\cmsis\Device\ARM\CMSDK_CM0plus\Include; ..\..\..\..\software\common\retarget
  memory RVCT1: ROM 0x0 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x10000
  group Startup
    ../../../../software/cmsis/Device/ARM/CMSDK_CM0plus/Source/ARM/: startup_CMSDK_CM0plus.s
  group Application
    ../../../../software/common/demos/: interrupt_demo.c
    ../../../../software/common/retarget/: retarget.c uart_stdout.c
    ../../../../software/cmsis/Device/ARM/CMSDK_CM0plus/Source/: CMSDK_driver.c
  group System
    ../../../../software/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
