# Keil uVision project debugtester_cm0plus_be.uvproj, settings and files
target Debug (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: debugtester_be
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output debugtester_be.hex
  c flags: Optim=3
  c define: CORTEX_M0PLUS DEBUGTESTER_BE
  c include: ..\cmsis\CMSIS\Include; ..\cmsis\Device\ARM\CMSDK_CM0\Include
  memory RVCT1: ROM 0x0 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x4000
  scatter file: debugtester_cm0plus.sct
  group Startup
    ../cmsis/Device/ARM/CMSDK_CM0PLUS/Source/ARM/: startup_CMSDK_CM0PLUS.s
  group Application
    ./: debugtester.c
  group System
    ./: system_cmsdk_debugtester.c retarget_cmsdk_debugtester.c
