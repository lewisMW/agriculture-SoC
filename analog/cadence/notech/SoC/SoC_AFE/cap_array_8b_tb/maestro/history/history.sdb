<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Feb 23 13:54:50 2026</timestamp>
			<uuid>{35e0b6cc-3326-4ce0-bb99-a04ab13bdd25}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/hee/projects/agriculture-SoC/analog/cadence/notech/SoC/SoC_AFE/cap_array_8b_tb/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>/home/hee/projects/agriculture-SoC/analog/cadence/notech/SoC/SoC_AFE/cap_array_8b_tb/maestro/results/maestro/ExplorerRun.0.rdb</simresults>
			<runlog>/home/hee/projects/agriculture-SoC/analog/cadence/notech/SoC/SoC_AFE/cap_array_8b_tb/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir></psfdir>
			<simdir></simdir>
		</historyentry>
	</history>
</setupdb>
